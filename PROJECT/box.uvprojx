# Keil uVision project box.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F100C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: box +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD_VL,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\LIB\inc;..\SYSTEM;..\USER;..\FatFs;..\sd;..\BMP280;..\LIBC\inc;..\MPU9250;..\SIM868
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md_vl.s
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c
  group LIB
    ../LIB/scr/: led.c key.c exti.c spi.c
  group LIBC
    ../LIBC/scr/: only_atof.c only_atoi.c only_strstr.c
  group SIM868
    ../SIM868/: crc16.c gps.c SIM868.c
  group MPU9250
    ../MPU9250/: mpu9250.c
  group BMP280
    ../BMP280/: bmp280.c
  group SD
    ../sd/: sd.c
  group FATFS
    ../FatFs/: diskio.c ff.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group README
    ../README/: README.txt
